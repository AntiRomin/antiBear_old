# Keil uVision project antiBear.uvprojx, settings and files
target antiBear (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: antiBear +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\lib\main\CMSIS\Core\Include;..\lib\main\STM32H7\Drivers\STM32H7xx_HAL_Driver\Inc\;..\lib\main\STM32H7\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\lib\main\STM32H7\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\src\main;..\src\main\startup;..\src\main\vcp;..\src\main\core;..\src\main\drivers
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group lib/hal_driver
    ../lib/main/STM32H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group src
    ../src/main/: main.c stm32h7xx_hal_msp.c
  group src/startup
    ../src/main/startup/: startup_stm32h743xx.s system_stm32h7xx.c
  group src/vcp
    ../src/main/vcp/: stm32h7xx_it.c
  group src/core
    ../src/main/core/: init.c app.c
  group src/drivers
    ../src/main/drivers/: system.c io.c timer.c pwm.c light_led.c light_rgb.c
software components: CMSIS:CORE 4.3.0
